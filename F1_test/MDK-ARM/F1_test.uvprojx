# Keil uVision project F1_test.uvprojx, settings and files
target F1_PWM_SWEEP (5060960::V5.06 update 7 (build 960)::ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800F7FF) CLOCK(64000000) CPUTYPE("Cortex-M3") TZ
  output: F1_PWM_SWEEP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,F1_TEST_WATCH_MODE=0
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x08000000 size 0x0000F800
  memory RVCT9: RAM 0x20000000 size 0x00005000
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/ScopeLab
    ../Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c main_pwm.c main_pwm_port.c main_pwm_bench.c main_pwm_sweep.c
    ./: startup_stm32f103xb.s
target F1_PWM_TEST (5060960::V5.06 update 7 (build 960)::ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: F1_PWM_TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,F1_TEST_WATCH_MODE=1
  c include: as above
  memory RVCT4: ROM 0x08000000 size 0x0000F800
  memory RVCT9: RAM 0x20000000 size 0x00005000
